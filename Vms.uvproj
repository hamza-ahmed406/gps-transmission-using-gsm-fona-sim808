# Keil uVision project Vms.uvproj, settings and files
target tracking device (ARM-ADS)
  device: TM4C123GH6PGE Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: uart_echo
  AfterMake: fromelf --bin --output .\rvmdk\uart_echo.bin .\rvmdk\uart_echo.axf
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: rvmdk PART_TM4C123GH6PGE TARGET_IS_BLIZZARD_RB1
  c misc: --c99
  c include: ..;..\..\..\..;..\..\..\..\third_party
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: uart_echo.sct
  link misc: --entry Reset_Handler
  group Source
    ../drivers/: cfal96x64x16.c buttons.c
    ./: startup_rvmdk.S main.c GSM_FONA808.c strfunc.c uartConfiguration.c SysTick.c lcd.c scheduler.c GPS_FONA.c sd_card.c
    ../../../../utils/: ustdlib.c cmdline.c uartstdio.c
    ../../../../third_party/fatfs/port/: mmc-dk-tm4c123g.c
    ../../../../third_party/fatfs/src/: ff.c
    ../../../../third_party/fatfs/src/option/: cc932.c
  group Libraries
    ../../../../driverlib/rvmdk/: driverlib.lib
    ../../../../grlib/rvmdk/: grlib.lib
  group Documentation
    ./: readme.txt
